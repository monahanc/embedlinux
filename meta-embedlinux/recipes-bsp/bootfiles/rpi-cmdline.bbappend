# Root partition (roota=mmcblk0p5 / rootb=mmcblk0p6) is appended dynamically by U-Boot
CMDLINE_ROOTFS = "${CMDLINE_ROOT_FSTYPE} rootwait"
